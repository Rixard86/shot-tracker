## firmware/boards/shotpuck/shotpuck/board.yml
```yaml
board:
  name: shotpuck
  full_name: ShotPuck (u-blox BMD-340 / nRF52840)
  vendor: shotpuck
  socs:
  - name: nrf52840
```
